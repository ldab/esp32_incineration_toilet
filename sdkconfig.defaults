## sdkconfig.defaults
```kconfig
CONFIG_SPI_FLASH_USE_LEGACY_IMPL=y
CONFIG_BOOTLOADER_LOG_LEVEL_DEBUG=y
CONFIG_ESP_COREDUMP_ENABLE_TO_UART=y
```
